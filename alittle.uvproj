# Keil uVision project alittle.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: alittle
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f429_439xx.s
  group User
    ./: main.c
  group Doc
    ./: ReadMe.txt
